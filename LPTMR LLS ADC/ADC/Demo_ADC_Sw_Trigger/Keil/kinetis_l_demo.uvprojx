# Keil uVision project kinetis_l_demo.uvprojx, settings and files
target DebugInFlash (ARM-ADS)
  device: MKL26Z128xxx4 Freescale Semiconductor
  pack: Keil.Kinetis_KLxx_DFP.1.6.0
  cpu: IRAM(0x1FFFF000-0x1FFFFFFF) IRAM2(0x20000000-0x20002FFF) IROM(0x0-0x1FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0+") ELITTLE
  output: MKL_DebugInFlash +hex
  AfterMake: #K\ARM\ARMCC\bin\fromelf.exe --bincombined --output=.\DebugInFlash\@L.bin !L
  c flags: Optim=1
  c define: KEIL FREEDOM CMSIS
  c include: ..\Source\App;..\Source\common;..\Source\common\headers;..\Source\Drv\adc;..\Source\Drv\uart;..\Source\Drv\lptmr
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x1ffff000 size 0x1000
  memory RVCT10: RAM 0x20000000 size 0x3000
  group StartUp
    ../Source/common/: system_MKL25Z4.c arm_cm0.c startup_MKL25Z4.s
  group APP
    ../Source/App/: main.c includes.h
  group Drv
    ../Source/Drv/adc/: MKL_adc.c
    ../Source/Drv/uart/: MKL_uart.c retarget_mdk.c
    ../Source/Drv/lptmr/: MKL_lptmr.c
